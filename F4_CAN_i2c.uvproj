# Keil uVision project F4_CAN_i2c.uvproj, settings and files
target f4_can (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: F4_CAN +hex
  c flags: Optim=1
  c define: HSE_VALUE=8000000
  c include: .\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ./: startup_stm32f40xx.s system_stm32f4xx.c
  group src
    ./src/: main.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_it.c stm32f4xx_can.c misc.c phil_pwm.c phil_rele.c stm32f4xx_i2c.c stm32f4xx_usart.c stm32f4xx_tim.c phil_i2c.c phil_nvic.c stm32f4xx_exti.c stm32f4xx_syscfg.c phil_typedefs.c
